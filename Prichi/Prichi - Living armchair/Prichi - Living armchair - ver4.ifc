Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Prichi - Living armchair - ver4.ifc
Time: 2024-01-15T09:35:01
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (42)
Name
 | Prichi - Living armchair model_0 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_1 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_2 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_3 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_4 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_5 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_6 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_7 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_8 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_9 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_10 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_11 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_12 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_13 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_14 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_15 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_16 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_17 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_18 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_19 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_20 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_21 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_22 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_23 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_24 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_25 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_26 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_27 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_28 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_29 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_30 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_31 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_32 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_33 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_34 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_35 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_36 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_37 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_38 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_39 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_40 - ObjectType: SketchupGroup
 | Prichi - Living armchair model_41 - ObjectType: SketchupGroup
